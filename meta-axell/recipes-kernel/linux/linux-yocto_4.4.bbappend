FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://kernel_opts.cfg"
