EXTRA_OECONF_append = " --enable-glx-demos"
